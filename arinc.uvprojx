# Keil uVision project arinc.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1986BE3T Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: arinc +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: D:\mcu\example\lin_buf
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group src
    ./: main.c
    D:/mcu/example/lin_buf/: lib_linear_buffer.c
  group inc
    D:/mcu/example/lin_buf/: lib_linear_buffer.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.3, Drivers:ARINC429R 2.0.3, Drivers:ARINC429T 2.0.3, Drivers:EEPROM 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3
